# Keil uVision project TK3000.uvproj, settings and files
target TK3000 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: TK3000 +hex
  AfterMake: fromelf.exe --bin -o ../OUTPUT/TK3000.bin  ../OUTPUT/TK3000.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F4XX,USE_USB_OTG_FS, USE_EMBEDDED_PHY, USE_STDPERIPH_DRIVER, __FPU_PRESENT = 1,__FPU_USED = 1,ARM_MATH_CM4, __CC_ARM
  c misc: --c99 --locale=english --diag_suppress=870
  c include: ..\STM32F40x_FWLib\inc;..\STM32F40x_FWLib\src;..\USER;..\CORE;.\Public;.\FreeRTOS;.\FreeRTOS\include;.\BSP;.\USBH_APP;..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\Libraries\STM32_USB_HOST_Library\Core\inc;..\Libraries\STM32_USB_OTG_Driver\inc;.\USBD_APP;..\Libraries\STM32_USB_Device_Library\Class\msc\inc;..\Libraries\STM32_USB_Device_Library\Core\inc;.\DAL;.\BLL;.\COM;.\WIFI;.\Motion;.\UI
  library: MicroLIB
  memory RVCT4: ROM 0x8040000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c readme.txt
  group BSP
    ./BSP/: exti.c gpio.c nvic.c stm32f4xx_it.c Timer.c RTC_F4xx.c SRAM_SFMC.c Timekeeper.c MemoryAlloc.h
  group BLL
    ./BLL/: AppTasks.c Register.c WorkControl.c WorkControlSuck.c WorkControlBlow.c WorkControlOut.c WorkControlCustomMove.c USBFunc.c
  group Motion
    ./Motion/: AxisControl.c MotorControl.c AxisRunningAction.c AxisLinkage.c MotionProc.c TCurve.c CurveBase.c SCurve_Table.c
  group COM
    ./COM/: CMD.c Protocol.c WIFIConfig.c WIFI.c COM_1.c COM_3.c
  group DAL
    ./DAL/: PortConfigFile.c FileOperate.c Parameter.c SST25V.c SysParameter.c CoordFile.c STMFlash.c WorkDataFile.c MotionProcFile.c FlashDisk.c
  group Public
    ./Public/: Delay.c PublicFunction.c DES.c DateTime.c Encrypt_XYQ.c Handlers.h
  group FWLIB
    ../STM32F40x_FWLib/src/: stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c misc.c
    ../STM32F40x_FWLib/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group FATFS
    ./FATFS/src/: diskio.c ff.c
    ./FATFS/src/option/: cc936.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c heap_2.c list.c port.c queue.c tasks.c timers.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group USB_Host_Driver
    ../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
    ../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USBH_APP
    ./USBH_APP/: usb_bsp.c usbh_usr.c
  group USBD_APP
    ./USBD_APP/: usb_it.c usbd_desc.c usbd_storage_msd.c usbd_usr.c
  group USBD_Lib
    ../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_OTG
    ../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_dcd_int.c
  group UI
    ./UI/: MainForm.c
